# IAR project power_manager.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK; SDK_OS_BAREMETAL; SDK_DEBUGCONSOLE=1; CR_INTEGER_PRINTF; SERIAL_PORT_TYPE_UART=1; __USE_CMSIS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ..; ../SDK_to_add; ../../../../../../devices/MCXN947/utilities/str; ../../../../../../devices/MCXN947/utilities/debug_console_lite; ../../../../../../devices/MCXN947/drivers; ../../../../../../devices/MCXN947; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../components/power_manager/core; ../../../../../../components/power_manager/boards/MCX-N9XX-EVK; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: power_manager.srec
  ILINK.IlinkOutputFile: power_manager.out
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/power_manager
    ../../../../../../components/power_manager/: README.md
  group component/power_manager/boards/MCX-N9XX-EVK
    ../../../../../../components/power_manager/boards/MCX-N9XX-EVK/: fsl_pm_board.c fsl_pm_board.h fsl_pm_board_config.h
  group component/power_manager/core
    ../../../../../../components/power_manager/core/: fsl_pm_config.h fsl_pm_core.c fsl_pm_core.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_clock.c fsl_clock.h fsl_cmc.c fsl_cmc.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dac.c fsl_dac.h fsl_dac14.c fsl_dac14.h fsl_gpio.c fsl_gpio.h fsl_lpcmp.c fsl_lpcmp.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_opamp.c fsl_opamp.h fsl_port.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spc.c fsl_spc.h fsl_vbat.c fsl_vbat.h fsl_vref.c fsl_vref.h fsl_wuu.c fsl_wuu.h
  group SDK_to_add
    ../SDK_to_add/: fsl_spc_to_add.h
  group source
    ../: analog.c analog.h lab_use-case.c power.c power.h power_manager.c power_manager.h timers.c timers.h
  group startup
    ../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group utilities
    ../../../../../../devices/MCXN947/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
